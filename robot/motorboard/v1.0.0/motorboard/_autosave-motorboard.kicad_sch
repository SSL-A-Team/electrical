File: robot/motorboard/v1.0.0/motorboard/_autosave-motorboard.kicad_sch (KiCad schematic)
At the start: 22 parts

Commit message: bus fixes
Other:
- moved on the sheet: D?
